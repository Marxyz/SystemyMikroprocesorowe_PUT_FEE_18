# Keil uVision project zadanie6.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC831 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: zadanie6
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: IO.c main.c aduc831.h IO.h stdfloat.h stdint.h
